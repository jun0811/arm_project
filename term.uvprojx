# Keil uVision project term.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: term
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    C:/Keil_v5/ARM/Pack/ARM/CMSIS/lpc175x_6x_cmsis_driver_library/Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_uart.c
    ./: atopfix.c atop.c
software components: CMSIS:CORE 5.0.0, Board Support:LED 1.0.0, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
